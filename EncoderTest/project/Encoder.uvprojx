# Keil uVision project Encoder.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: SKEAZ128xxx4 NXP
  pack: Keil.Kinetis_KEAxx_DFP.1.3.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Encoder
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\CORE;..\DRIVER;..\LIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group CORE
    ../CORE/: startup_SKEAZ1284.s system_SKEAZ1284.c
  group LIB
    ../LIB/: motor.c encoder.c OLED.c
  group DRIVER
    ../DRIVER/: incap.c pwm.c gpio.c i2c.c pit.c
    ../LIB/: delay.c
  group USER
    ../USER/: isr.c main.c
