# Keil uVision project KBI.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: SKEAZ128xxx4 NXP
  pack: Keil.Kinetis_KEAxx_DFP.1.3.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: KBI
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\CORE;..\DRIVER;..\LIB;..\USER;..\USER\test
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group core
    ../CORE/: startup_SKEAZ1284.s system_SKEAZ1284.c
  group driver
    ../DRIVER/: gpio.c KBI.c i2c.c pit.c ADC.c pwm.c incap.c
  group lib
    ../LIB/: common.c OLED.c display.c delay.c accelerometer.c GYRO.c PID.c balanceControl.c encoder.c motor.c distance.c
  group test
    ../USER/: balance.c balance_isr.c
